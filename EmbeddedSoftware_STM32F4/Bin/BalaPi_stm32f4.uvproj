# Keil uVision project BalaPi_stm32f4.uvproj, settings and files
target balaPi (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BalaPi_stm32f4 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\inc;..\_Code_;..\_Code_\DEV;..\_Code_\Tools;..\_Code_\Timing;..\_Code_\Commnunication;..\_Code_\Control;..\_Code_\Sensor;..\_Code_\Storage;..\_Code_\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../_Code_/: BalaPi_BoardConf.h
    ../_Code_/User/: main.c TestOnLCD.c User_Interface.c Voltage_FB.c
  group Sensor
    ../_Code_/Sensor/: HMC5883L.c IMU.c MPU6050.c Sona.c
  group Tools
    ../_Code_/Tools/: Tool_DataProcessing.c
  group Storage
    ../_Code_/Storage/: EEPROM.c
  group Motor
    ../_Code_/Control/: encoder.c Motor.c Servo.c Speed_PID.c
  group TIMER
    ../_Code_/Timing/: Systick.c Timing_Manage.c
  group DEV Library
    ../_Code_/DEV/: Dev_DIGITAL.c Dev_LCD.c Dev_I2C.c Dev_USART.c Dev_TIMER.c
  group Peripheral Library
    ../src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group System
    ../_Code_/: system_stm32f4xx.c
    ../src/: stm32f4xx_syscfg.c
    ./: startup_stm32f4xx.s
  group Communication
    ../_Code_/Commnunication/: Serial_Link.c
